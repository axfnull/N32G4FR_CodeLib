# Keil uVision project MultiProcessor.uvprojx, settings and files
target N32G4FR (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: N32G4FRMEL7 Nationstech
  pack: Nationstech.N32G4FR_DFP.1.0.0
  cpu: IRAM(0x20000000,0x24000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: MultiProcessor +hex
  AfterMake: fromelf --bin --output=.\bin\MultiProcessor.bin .\Objects\MultiProcessor.axf
  AfterMake: fromelf --vhx -d --32x1 .\Objects\MultiProcessor.axf --output=.\bin\MultiProcessor.dua
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: N32G4FR, USE_STDPERIPH_DRIVER
  c include: ..\inc;..\..\..\..\..\..\firmware\CMSIS\core;..\..\..\..\..\..\firmware\CMSIS\device;..\..\..\..\..\..\firmware\n32g4fr_std_periph_driver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group STARTUP
    ../../../../../../firmware/CMSIS/device/startup/: startup_n32g4fr.s
  group CMSIS
    ../../../../../../firmware/CMSIS/device/: system_n32g4fr.c
  group FWLB
    ../../../../../../firmware/n32g4fr_std_periph_driver/src/: misc.c n32g4fr_exti.c n32g4fr_gpio.c n32g4fr_rcc.c n32g4fr_usart.c
  group USER
    ../src/: main.c n32g4fr_it.c bsp_key.c bsp_led.c
  group DOC
    ../: readme.txt
