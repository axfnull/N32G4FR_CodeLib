# IAR project RCC_ClockConfig.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: N32G4FRME Nations N32G4FRME
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: N32G4FR; USE_STDPERIPH_DRIVER; SYSCLK_FREQ=144000000
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\firmware\CMSIS\core; ..\..\..\..\..\..\firmware\CMSIS\device; ..\..\..\..\..\..\firmware\n32g4fr_std_periph_driver\inc; ..\..\..\..\bsp\inc; ..\inc
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: RCC_ClockConfig.bin
  ILINK.IlinkOutputFile: RCC_ClockConfig.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group CMSIS
    ../../../../../../firmware/CMSIS/device/: system_n32g4fr.c
  group DOC
    ../src/: readme.txt
  group FWLB
    ../../../../bsp/src/: delay.c log.c
    ../../../../../../firmware/n32g4fr_std_periph_driver/src/: misc.c n32g4fr_dbg.c n32g4fr_exti.c n32g4fr_flash.c n32g4fr_gpio.c n32g4fr_pwr.c n32g4fr_rcc.c n32g4fr_usart.c
  group STARTUP
    ../../../../../../firmware/CMSIS/device/startup/: startup_n32g4fr_EWARM.s
  group USER
    ../src/: main.c n32g4fr_it.c
