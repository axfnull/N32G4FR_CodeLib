# Keil uVision project TSC.uvprojx, settings and files
target N32G4FR (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: N32G4FRMEL7 Nationstech
  pack: Nationstech.N32G4FR_DFP.1.0.1
  cpu: IRAM(0x20000000,0x24000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: TSC +hex
  AfterMake: fromelf --bin --output=.\bin\TSC.bin .\Objects\TSC.axf
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: N32G4FR, USE_STDPERIPH_DRIVER, USE_FULL_ASSERT
  c include: ..\inc;..\..\..\..\..\..\firmware\CMSIS\core;..\..\..\..\..\..\firmware\n32g4fr_std_periph_driver\inc;..\..\..\..\..\..\firmware\CMSIS\device
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20020000 size 0x4000
  scatter file: .\TSC_HW.sct
  group Startup
    ../../../../../../firmware/CMSIS/device/startup/: startup_n32g4fr.s
  group CMSIS
    ../../../../../../firmware/CMSIS/device/: system_n32g4fr.c
  group Driver
    ../../../../../../firmware/n32g4fr_std_periph_driver/src/: misc.c n32g4fr_flash.c n32g4fr_gpio.c n32g4fr_rcc.c n32g4fr_rtc.c n32g4fr_tim.c n32g4fr_tsc.c n32g4fr_usart.c n32g4fr_exti.c n32g4fr_pwr.c n32g4fr_dbg.c
  group User
    ../src/: main.c delay.c n32g4fr_it.c
  group Bsp
    ../src/: bsp_usart.c bsp_gpio.c bsp_tsc.c
  group DOC
    ../: readme.txt
