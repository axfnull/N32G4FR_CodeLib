# IAR project TSC.ewp, settings and files
configuration N32G4FR (ARM, debug)
  General.OGChipSelectEditMenu: N32G4FRME Nations N32G4FRME
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: N32G4FR; USE_STDPERIPH_DRIVER; USE_FULL_ASSERT; _DLIB_FILE_DESCRIPTOR
  ICCARM.CCIncludePath2: ../inc; ../../../../../../firmware/CMSIS/core; ../../../../../../firmware/n32g4fr_std_periph_driver/inc; ../../../../../../firmware/CMSIS/device
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: template_project.out
  ILINK.IlinkIcfFile: $TOOLKIT_DIR$\config\linker\Nations\N32G4FR\N32G4FRxE.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Bsp
    ../src/: bsp_gpio.c bsp_timer.c bsp_tsc.c bsp_usart.c
  group CMSIS
    ../../../../../../firmware/CMSIS/device/: system_n32g4fr.c
  group DOC
    ../: readme.txt
  group Driver
    ../../../../../../firmware/n32g4fr_std_periph_driver/src/: misc.c n32g4fr_flash.c n32g4fr_gpio.c n32g4fr_pwr.c n32g4fr_rcc.c n32g4fr_rtc.c n32g4fr_tim.c n32g4fr_tsc.c n32g4fr_usart.c
  group Startup
    ../../../../../../firmware/CMSIS/device/startup/: startup_n32g4fr_EWARM.s
  group User
    ../src/: delay.c main.c n32g4fr_it.c
