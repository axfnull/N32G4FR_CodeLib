# IAR project Virtual_COM_Port_LoopBack.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: N32G4FRHE Nations N32G4FRHE
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: N32G4FR; USE_STDPERIPH_DRIVER; USE_FULL_ASSERT=1
  ICCARM.CCDiagSuppress: Pa084
  ICCARM.CCIncludePath2: ..\inc; ..\..\..\..\..\..\firmware\CMSIS\core; ..\..\..\..\..\..\firmware\CMSIS\device; ..\..\..\..\..\..\firmware\n32g4fr_std_periph_driver\inc; ..\..\..\..\..\..\firmware\n32g4fr_usbfs_driver\inc
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Virtual_COM_Port_LoopBack.bin
  ILINK.IlinkOutputFile: Virtual_COM_Port_LoopBack.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group CMSIS
    ../../../../../../firmware/CMSIS/device/: system_n32g4fr.c
  group DOC
    ../: readme.txt
  group FWLB
    ../../../../../../firmware/n32g4fr_std_periph_driver/src/: misc.c n32g4fr_exti.c n32g4fr_gpio.c n32g4fr_pwr.c n32g4fr_rcc.c n32g4fr_usart.c
  group n32g4fr_usbfs_driver
    ../../../../../../firmware/n32g4fr_usbfs_driver/src/: usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c usb_sil.c
  group STARTUP
    ../../../../../../firmware/CMSIS/device/startup/: startup_n32g4fr_EWARM.s
  group USER
    ../src/: hw_config.c main.c n32g4fr_it.c usb_desc.c usb_endp.c usb_istr.c usb_prop.c usb_pwr.c
