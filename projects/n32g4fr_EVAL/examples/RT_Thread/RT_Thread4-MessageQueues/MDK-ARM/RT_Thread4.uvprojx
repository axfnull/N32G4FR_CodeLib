# Keil uVision project RT_Thread4.uvprojx, settings and files
target N32G4FR (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: N32G4FRMEL7 Nationstech
  pack: Nationstech.N32G4FR_DFP.1.0.1
  cpu: IRAM(0x20000000,0x24000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: RT_Thread4 +hex
  AfterMake: fromelf --bin --output=.\bin\RT_Thread4.bin .\Objects\RT_Thread4.axf
  c flags: Optim=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: N32G4FR, USE_STDPERIPH_DRIVER
  c include: ..\inc;..\..\..\..\..\..\firmware\CMSIS\core;..\..\..\..\..\..\firmware\CMSIS\device;..\..\..\..\..\..\firmware\n32g4fr_std_periph_driver\inc;..\..\..\..\..\..\middlewares\rt-thread\include;..\app\inc;..\bsp\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x24000
  group STARTUP
    ../../../../../../firmware/CMSIS/device/startup/: startup_n32g4fr.s
  group CMSIS
    ../../../../../../firmware/CMSIS/device/: system_n32g4fr.c
  group FWLB
    ../../../../../../firmware/n32g4fr_std_periph_driver/src/: misc.c n32g4fr_gpio.c n32g4fr_rcc.c n32g4fr_usart.c
  group APP
    ../app/src/: application.c main.c n32g4fr_it.c
  group RT_Thread
    ../../../../../../middlewares/rt-thread/src/: clock.c components.c cpu.c device.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler.c signal.c slab.c thread.c timer.c
  group CORTEX-M4
    ../../../../../../middlewares/rt-thread/libcpu/cortex-m4/: context_rvds.S cpuport.c
  group BSP
    ../bsp/src/: bsp.c log.c led.c key.c
  group DOC
    ../: readme.txt
