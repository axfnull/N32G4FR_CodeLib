# Keil uVision project IIC_DEVICE_REGISTER.uvprojx, settings and files
target N32G4FR (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: N32G4FRMEL7 Nationstech
  pack: Nationstech.N32G4FR_DFP.1.0.3
  cpu: IRAM(0x20000000,0x24000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: IIC_DEVICE_REGISTER +hex
  AfterMake: fromelf --bin --output=.\bin\IIC_DEVICE_REGISTER.bin .\Objects\IIC_DEVICE_REGISTER.axf
  c flags: Optim=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: N32G4FR, USE_STDPERIPH_DRIVER
  c misc: --c99
  c include: ..\inc;..\..\..\..\..\..\firmware\CMSIS\core;..\..\..\..\..\..\firmware\CMSIS\device;..\..\..\..\..\..\firmware\n32g4fr_std_periph_driver\inc;..\..\..\..\..\..\middlewares\rt-thread\include;..\..\DeviceDrivers\gpio\inc;..\..\DeviceDrivers\i2c\inc;..\..\DeviceDrivers\uart\inc;..\..\..\..\..\..\middlewares\rt-thread\components\drivers\i2c;..\..\..\..\..\..\middlewares\rt-thread\components\drivers\include;..\..\..\..\..\..\middlewares\rt-thread\components\drivers\include\ipc;..\..\..\..\..\..\middlewares\rt-thread\components\drivers\include\drivers
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x24000
  group STARTUP
    ../../../../../../firmware/CMSIS/device/startup/: startup_n32g4fr.s
  group CMSIS
    ../../../../../../firmware/CMSIS/device/: system_n32g4fr.c
  group FWLB
    ../../../../../../firmware/n32g4fr_std_periph_driver/src/: misc.c n32g4fr_dma.c n32g4fr_exti.c n32g4fr_gpio.c n32g4fr_i2c.c n32g4fr_rcc.c n32g4fr_usart.c
  group USER
    ../src/: board.c i2c_eeprom.c main.c n32g4fr_it.c
  group RT_Thread
    ../../../../../../middlewares/rt-thread/src/: clock.c device.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler.c slab.c thread.c timer.c components.c cpu.c signal.c
  group CORTEX-M4
    ../../../../../../middlewares/rt-thread/libcpu/cortex-m4/: context_rvds.S cpuport.c
  group DOC
    ../: readme.txt
  group DeviceDrivers
    ../../DeviceDrivers/gpio/src/: drv_gpio.c
    ../../DeviceDrivers/i2c/src/: drv_i2c.c
    ../../DeviceDrivers/uart/src/: drv_usart.c
  group Drivers
    ../../../../../../middlewares/rt-thread/components/drivers/serial/: serial.c
    ../../../../../../middlewares/rt-thread/components/drivers/misc/: pin.c
    ../../../../../../middlewares/rt-thread/components/drivers/src/: completion.c
    ../../../../../../middlewares/rt-thread/components/drivers/i2c/: i2c_core.c i2c_dev.c
