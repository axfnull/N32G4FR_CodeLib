# Keil uVision project Mass_Stroage.uvprojx, settings and files
target N32G4FR (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: N32G4FRMEL7 Nationstech
  pack: Nationstech.N32G4FR_DFP.1.0.3
  cpu: IRAM(0x20000000,0x24000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Mass_Stroage +hex
  AfterMake: fromelf --bin --output=.\bin\Mass_Stroage.bin .\Objects\Mass_Stroage.axf
  c flags: Optim=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: N32G4FR, USE_STDPERIPH_DRIVER
  c misc: --c99
  c include: ..\inc;..\..\..\..\..\..\firmware\CMSIS\core;..\..\..\..\..\..\firmware\CMSIS\device;..\..\..\..\..\..\firmware\n32g4fr_std_periph_driver\inc;..\..\..\..\..\..\middlewares\rt-thread\include;..\..\DeviceDrivers\uart\inc;..\..\DeviceDrivers\gpio\inc;..\..\..\..\..\..\middlewares\rt-thread\components\drivers\include\drivers;..\..\..\..\..\..\middlewares\rt-thread\components\drivers\include;..\..\..\..\..\..\middlewares\rt-thread\components\drivers\include\ipc;..\..\..\..\..\..\middlewares\rt-thread\components\drivers\cherryusb\class\msc;..\..\..\..\..\..\middlewares\rt-thread\components\drivers\cherryusb\core;..\..\..\..\..\..\middlewares\rt-thread\components\drivers\cherryusb\port\fsdev;..\..\..\..\..\..\middlewares\rt-thread\components\drivers\cherryusb\common
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x24000
  group STARTUP
    ../../../../../../firmware/CMSIS/device/startup/: startup_n32g4fr.s
  group CMSIS
    ../../../../../../firmware/CMSIS/device/: system_n32g4fr.c
  group FWLB
    ../../../../../../firmware/n32g4fr_std_periph_driver/src/: misc.c n32g4fr_exti.c n32g4fr_flash.c n32g4fr_gpio.c n32g4fr_rcc.c n32g4fr_usart.c
  group USER
    ../src/: board.c main.c mass_storage.c n32g4fr_it.c
  group RT_Thread
    ../../../../../../middlewares/rt-thread/src/: clock.c device.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler.c slab.c thread.c timer.c components.c cpu.c signal.c
  group CORTEX-M4
    ../../../../../../middlewares/rt-thread/libcpu/cortex-m4/: context_rvds.S cpuport.c
  group DOC
    ../: readme.txt
  group Drivers
    ../../../../../../middlewares/rt-thread/components/drivers/misc/: pin.c
    ../../../../../../middlewares/rt-thread/components/drivers/serial/: serial.c
    ../../../../../../middlewares/rt-thread/components/drivers/src/: completion.c
  group Device_Drivers
    ../../DeviceDrivers/uart/src/: drv_usart.c
    ../../DeviceDrivers/gpio/src/: drv_gpio.c
  group USB_Stack
    ../../../../../../middlewares/rt-thread/components/drivers/cherryusb/class/msc/: usbd_msc.c
    ../../../../../../middlewares/rt-thread/components/drivers/cherryusb/core/: usbd_core.c
    ../../../../../../middlewares/rt-thread/components/drivers/cherryusb/port/fsdev/: usb_dc_fsdev.c
